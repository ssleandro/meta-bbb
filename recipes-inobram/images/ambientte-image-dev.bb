require ambientte-image.bb

CORE_IMAGE_EXTRA_INSTALL += "\
    packagegroup-inobram-development \
"
