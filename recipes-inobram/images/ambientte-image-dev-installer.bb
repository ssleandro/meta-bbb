require ambientte-image-installer.bb
