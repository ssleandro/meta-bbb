require smaai5-image.bb

WKS_FILE = "${MACHINE}-2gb-installer.wks"
