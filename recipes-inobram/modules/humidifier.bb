require inobram-setuptools.inc
require inobram-manager-setuptools.inc
