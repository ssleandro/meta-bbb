require smaai5.inc

RDEPENDS_${PN} += " \
    python3-datetime \
    python3-db \
"
