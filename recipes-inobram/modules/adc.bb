require inobram.inc

RDEPENDS_${PN} += " \
    python3-adafruit-bbio \
    python3-db \
"
