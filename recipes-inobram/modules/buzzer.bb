require inobram.inc

SRCBRANCH = "master"

RDEPENDS:${PN} += " \
    python3-datetime \
"
