require inobram-setuptools.inc

SRCBRANCH = "ambientte_1.0.x"

RDEPENDS_${PN} += " \
    python3-datetime \
"
