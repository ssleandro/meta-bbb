require inobram.inc

FILES_${PN} += "${libdir}"
