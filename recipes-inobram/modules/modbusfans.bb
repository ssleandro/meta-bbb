require inobram.inc

RDEPENDS:${PN} += " \
    python3-pyserial \
"
