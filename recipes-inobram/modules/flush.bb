require inobram-setuptools.inc
require inobram-manager-setuptools.inc

RDEPENDS:${PN} += "\
    python3-requests \
"
