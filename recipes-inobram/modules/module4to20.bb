require inobram-setuptools.inc

RDEPENDS:${PN} += "module4to20"
