require smaai5.inc

RDEPENDS_${PN} += " \
    i2c-tools \
    python3-adafruit-bbio \
    python3-datetime \
"
