FILESPATH_prepend := "${THISDIR}/${PN}:"
