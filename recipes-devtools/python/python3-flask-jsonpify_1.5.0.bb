require python-flask-jsonpify.inc
inherit pypi setuptools3
