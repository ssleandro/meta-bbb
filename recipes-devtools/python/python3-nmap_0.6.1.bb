require python-nmap.inc
inherit pypi setuptools3
