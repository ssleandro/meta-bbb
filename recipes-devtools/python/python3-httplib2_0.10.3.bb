require python-httplib2.inc
inherit pypi setuptools3
