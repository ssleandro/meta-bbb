require python-speedtest-cli.inc
inherit setuptools
