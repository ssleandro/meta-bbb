require python-pyjwt.inc
inherit pypi setuptools
