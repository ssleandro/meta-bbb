FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-ADAFRUIT-SPI0-00A0-Free-up-the-pins-used-by-the-cape.patch"
