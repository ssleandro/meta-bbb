DESCRIPTION = "The zope.event package provides a simple event system"
SECTION = "devel/python"
LICENSE = "CLOSED"

SRC_URI[sha256sum] = "81d98813046fc86cc4136e3698fee628a3282f9c320db18658c21749235fce80"

inherit pypi setuptools3
