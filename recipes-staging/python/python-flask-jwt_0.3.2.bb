require python-flask-jwt.inc
inherit pypi setuptools
