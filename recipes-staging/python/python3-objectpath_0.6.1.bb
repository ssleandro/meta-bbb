DESCRIPTION = "The agile NoSQL query language for semi-structured data"
SECTION = "devel/python"
LICENSE = "CLOSED"

DEPENDS += "dtc-native"

SRC_URI[sha256sum] = "461263136c79292e42431fbb85cdcaac4c6a256f6b1aa5b3ae9316e4965ad819"

inherit pypi setuptools3
