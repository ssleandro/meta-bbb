require python-repo.inc
inherit python-dir
