require python-repo.inc
inherit python3-dir

SRC_URI += "file://repo-Change-env-to-use-python3.patch"
