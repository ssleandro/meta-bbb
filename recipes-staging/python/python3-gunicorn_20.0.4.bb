require python-gunicorn.inc
inherit pypi setuptools3
