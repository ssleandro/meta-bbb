DESCRIPTION = "A library for parsing ISO 8601 strings."
SECTION = "devel/python"
LICENSE = "CLOSED"

SRC_URI[sha256sum] = "72e3117667eedf66951bb2d93f4296a56b94b078a8a95905a052611fb3f1b973"

inherit pypi setuptools3
