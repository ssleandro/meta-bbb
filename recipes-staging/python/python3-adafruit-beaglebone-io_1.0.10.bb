require python-adafruit-beaglebone-io.inc
inherit setuptools3
