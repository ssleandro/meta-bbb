require smaai5.inc

RDEPENDS_${PN} += " \
    python-datetime \
    python-db \
"
