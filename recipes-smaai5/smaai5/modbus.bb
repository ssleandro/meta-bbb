require smaai5.inc

SRCBRANCH = "modbus-v2.0"

RDEPENDS_${PN} += " \
    python-pyserial \
"
