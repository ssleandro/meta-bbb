require smaai5.inc
