require smaai5.inc

RDEPENDS_${PN} += " \
    i2c-tools \
    python3-adafruit-beaglebone-io \
    python3-datetime \
"
