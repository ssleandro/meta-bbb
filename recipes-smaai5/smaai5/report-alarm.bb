require smaai5.inc

FILES_${PN} += "${libdir}"
