require smaai5.inc

RDEPENDS_${PN} += " \
    python-adafruit-beaglebone-io \
    python-db \
"
