require smaai5.inc

RDEPENDS_${PN} += " \
   python-datetime \
   python-sqlite3 \
   sqlite3 \
"
