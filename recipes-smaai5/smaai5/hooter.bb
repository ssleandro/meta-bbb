require smaai5.inc

RDEPENDS_${PN} += " \
    python3-adafruit-bbio \
    python3-datetime \
"
