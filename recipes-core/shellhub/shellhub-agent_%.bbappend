FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-agent-Allow-setting-the-log-level-to-use.patch;patchdir=${S}/src/${GO_IMPORT}"
