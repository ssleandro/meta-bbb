FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "\
    file://disable_module_compress.cfg \
    file://smaai5_cmdline.cfg \
"
