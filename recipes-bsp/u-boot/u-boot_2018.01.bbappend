SRC_URI += " \
    file://0001-am335x_evm-uEnv.txt-bootz-n-fixes.patch \
    file://0002-U-Boot-BeagleBone-Cape-Manager.patch \
    file://0003-ti_armv7_common-Set-bootfile-to-zImage.patch \
    file://0004-am335x_evm_defconfig-Set-CONFIG_SYS_EXTRA_OPTIONS-to.patch \
"
