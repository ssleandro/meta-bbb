require u-boot-inobram-common.inc
require recipes-bsp/u-boot/u-boot-tools.inc
