# FIXME: Remove this when updating platform
RDEPENDS_${PN}_remove = "python"
RDEPENDS_${PN} += "python3-core"
